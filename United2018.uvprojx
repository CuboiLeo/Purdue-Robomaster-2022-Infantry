# Keil uVision project United2018.uvprojx, settings and files
target United2018 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: United2018 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F427X,USE_STDPERIPH_DRIVER,__FPU_USED,__FPU_PRESENT,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: .\Applications;.\Drivers;.\Libraries\StartUp;.\Libraries\FWLIB\inc;.\Libraries\CORE;.\SYSTEM\usart;.\SYSTEM\sys;.\SYSTEM\delay;.\USER;.\POWER;.\FreeRtos\include;.\FreeRtos\portable\RVDS\ARM_CM4F;.\Drivers\MPU6050OUT\eMPL
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Libraries
    ./Libraries/StartUp/: startup_stm32f427xx.s system_stm32f4xx.c
    ./Libraries/FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_dbgmcu.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group SYSTEM
    ./SYSTEM/delay/: delay.c
    ./SYSTEM/sys/: sys.c
    ./SYSTEM/usart/: usart.c
  group Drivers
    ./Drivers/: buzzer.c can1.c can2.c led.c MPU6500.c pwm.c RemoteControl.c timer.c spi.c Comm_umpire.c laser.c CRC.c myiic.c Usart_SendData.c
    ./Drivers/MPU6050OUT/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ./Drivers/MPU6050OUT/: mpu6050out.c
  group Applications
    ./Applications/: Ctrl_chassis.c Ctrl_gimbal.c filter.c Higher_Class.c IMU.c User_API.c PID.c Kalman.c Ctrl_shoot.c start_task.c
  group User
    ./USER/: main.c stm32f4xx_it.c Configuration.h
  group POWER
    ./POWER/: Power.c
  group FreeRtos_CORE
    ./FreeRtos/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ./FreeRtos/portable/RVDS/ARM_CM4F/: port.c
    ./FreeRtos/portable/MemMang/: heap_4.c
